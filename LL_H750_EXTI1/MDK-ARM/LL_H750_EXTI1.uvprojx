# Keil uVision project LL_H750_EXTI1.uvprojx, settings and files
target LL_H750_EXTI1 (6180000::V6.18::ARMCLANG)
  device: STM32H750IBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: LL_H750_EXTI1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32H750xx,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300
  c include: ../Core/Inc;C:/Users/EPS5-PC/STM32Cube/Repository/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Inc;C:/Users/EPS5-PC/STM32Cube/Repository/STM32Cube_FW_H7_V1.11.0/Drivers/CMSIS/Device/ST/STM32H7xx/Include;C:/Users/EPS5-PC/STM32Cube/Repository/STM32Cube_FW_H7_V1.11.0/Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c
  group Drivers/STM32H7xx_HAL_Driver
    C:/Users/EPS5-PC/STM32Cube/Repository/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_bdma.c stm32h7xx_ll_pwr.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
software components: CMSIS:CORE 5.6.0
